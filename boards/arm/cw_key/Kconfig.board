## boards/arm/cw_key/Kconfig.board
```kconfig
config BOARD_CW_KEY
    bool "CW Key"
    imply RETAINED_MEM
    imply RETENTION
    imply RETENTION_BOOT_MODE
```
